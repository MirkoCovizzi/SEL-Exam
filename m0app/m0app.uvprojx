# Keil uVision project m0app.uvprojx, settings and files
target m0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: m0app
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS\CMSIS\Include;..\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\lpc_core\lpc_chip\chip_18xx_43xx;..\lpc_core\lpc_chip\chip_common;..\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\lpc_core\lpc_board\board_common;..\multicore_common;..\m0app
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10080000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: main.c
    ../startup_code/: keil_startup_lpc43xx_m0app.s sysinit.c
    ../multicore_common/: ipc_example.c ipc_msg.c m0_img_ldr.c
  group lib
    ../lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m0/: lib_lpc_board_nxp_lpcxpresso_4337_m0.lib
    ../lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
