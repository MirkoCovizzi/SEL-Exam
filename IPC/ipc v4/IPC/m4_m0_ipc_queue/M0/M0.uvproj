# Keil uVision project M0.uvproj, settings and files
target LPC43xx_M0_RAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_RAM +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\RAM\CM0_RAM.axf"
  c flags: OneElfS=1
  c define: CORE_M0 IPC_SLAVE
  c include: ..\..\..\common;..\..\api\queue\inc;.\;..\platform
  asm define: NO_CRP IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: ..\platform\M0_Ram.sct
  link misc: --pad=0xFF
  group System Code
    ../../../common/: scu.c core_cm0.c system_LPC43xx.c
    ../platform/: startup_LPC43xx_M0.s
  group Ipc
    ../../api/queue/src/: ipc_queue.c ipc_cmd_buffer.c ipc_msg_buffer.c
  group Platform
    ../platform/: platform_config.h
  group Source Code
    ./: main.c
target LPC43xx_M0_FLASH (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_FLASH +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\FLASH\CM0_FLASH.axf"
  c define: CORE_M0  IPC_SLAVE
  c include: ..\..\..\common;..\..\api\queue\inc;.\;..\platform
  asm define: NO_CRP  IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: ..\platform\M0_Flash.sct
  link misc: --pad=0xFF
