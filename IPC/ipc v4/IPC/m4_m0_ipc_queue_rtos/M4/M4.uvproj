# Keil uVision project M4.uvproj, settings and files
target LPC43xx_M4_RAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: LPC43xx_M4_RAM +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER
  c include: .\;..\..\..\common;..\..\api\queue\inc;.\M0_image;..\platform;..\..\..\FreeRTOS\inc;..\..\..\FreeRTOS\CM3\rvds
  asm define: NO_CRP IPC_MASTER
  library: MicroLIB
  scatter file: ..\platform\M4_Ram.sct
  link misc: --debug --pad=0xFF  --keep=ipc_cmd_buffer.o(cmdBuffer_section) --keep=ipc_msg_buffer.o(msgBuffer_section)
  group System Code
    ../../../common/: scu.c core_cm4.c system_LPC43xx.c reloc_irq_table.c emc_LPC43xx.c fpu_init.c
    ../platform/: startup_LPC43xx.s
  group Ipc
    ../../api/queue/src/: ipc_queue.c ipc_cmd_buffer.c ipc_msg_buffer.c
  group Platform
    ./: M4_RAM.ini
    ../platform/: platform_config.h FreeRTOSConfig.h platform_config.c
    ./M0_image/: CM0_image.c
  group Source Code
    ./: main.c
  group FreeRTOS
    ../../../FreeRTOS/src/: croutine.c heap_2.c list.c queue.c tasks.c timers.c
    ../../../FreeRTOS/CM3/rvds/: port.c
target LPC43xx_M4_FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: LPC43xx_M4_FLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 EXT_FLASH EXT_STAT_MEM IPC_MASTER
  c include: ..\..\..\common;..\..\api\queue\inc;.\M0_image;..\platform;..\..\..\FreeRTOS\inc;..\..\..\FreeRTOS\CM3
  asm define: NO_CRP EXT_FLASH IPC_MASTER
  library: MicroLIB
  scatter file: ..\platform\M4_Flash.sct
  link misc: as above
