# Keil uVision project M0.uvproj, settings and files
target LPC43xx_M0_RAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_RAM +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\RAM\CM0_RAM.axf"
  c flags: OneElfS=1
  c define: CORE_M0 IPC_SLAVE
  c include: ..\..\..\common;..\..\api\mbx\inc;.\;.\M0_rpc;..\M4\M4_rpc;..\platform;..\..\..\FreeRTOS\inc;..\..\..\FreeRTOS\CM0\rvds
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: ..\platform\M0_Ram.sct
  link misc: --pad=0xFF  --keep=ipc_buffer.o(Slave_mbxTable)
  group Ipc
    ../../api/mbx/src/: ipc_buffer.c ipc_mbx.c
  group System Code
    ../platform/: startup_LPC43xx_m0.s
    ../../../common/: core_cm0.c scu.c system_LPC43xx.c
  group Source Code
    ./: main.c
    ./M0_rpc/: slave_mbx_callbacks.c
  group platform
    ../platform/: platform_config.h
    ./: FreeRTOSConfig.h
  group FreeRTOS
    ../../../FreeRTOS/src/: croutine.c heap_2.c list.c queue.c tasks.c timers.c
    ./: osTimerConfig.c
    ../../../FreeRTOS/CM0/rvds/: port.c
target LPC43xx_M0_FLASH (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_FLASH +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\FLASH\CM0_FLASH.axf"
  c define: CORE_M0 IPC_SLAVE
  c include: ..\..\..\common;..\..\api\mbx\inc;.\;.\M0_rpc;..\M4\M4_rpc;..\platform;..\..\..\FreeRTOS\inc;..\..\..\FreeRTOS\CM0
  asm define: NO_CRP IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: ..\platform\M0_Flash.sct
  link misc: --pad=0xFF --keep=ipc_buffer.o(Slave_mbxTable)
