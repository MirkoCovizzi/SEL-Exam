# Keil uVision project M0.uvproj, settings and files
target LPC43xx_M0_RAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_RAM +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\RAM\CM0_RAM.axf"
  c define: CORE_M0 IPC_SLAVE
  c include: .\;..\..\..\common;..\..\api\queue\inc;..\platform;..\..\..\FreeRTOS\inc;..\..\..\FreeRTOS\CM0\rvds
  asm define: NO_CRP  IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: ..\platform\M0_Ram.sct
  link misc: --pad=0xFF
  group Ipc
    ../../api/queue/src/: ipc_queue.c
  group System Code
    ../../../common/: scu.c core_cm0.c system_LPC43xx.c
    ../platform/: startup_LPC43xx_M0.s
  group Source Code
    ./: main.c
  group Platform
    ../platform/: platform_config.h platform_check.h
    ./: FreeRTOSConfig.h
  group FreeRTOS
    ../../../FreeRTOS/src/: croutine.c heap_2.c list.c queue.c tasks.c timers.c
    ./: osTimerConfig.c
    ../../../FreeRTOS/CM0/rvds/: port.c
target LPC43xx_M0_FLASH (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_FLASH +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\FLASH\CM0_FLASH.axf"
  c define: CORE_M0
  c include: ..\..\..\common;..\..\api\queue\inc;..\platform;..\..\..\FreeRTOS\inc;..\..\..\FreeRTOS\CM0
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: ..\platform\M0_Flash.sct
  link misc: --pad=0xFF
