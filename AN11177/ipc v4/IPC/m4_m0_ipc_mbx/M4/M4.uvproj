# Keil uVision project M4.uvproj, settings and files
target LPC43xx_M4_RAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: LPC43xx_M4_RAM +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER
  c include: ..\..\..\common;..\..\api\mbx\inc;..\M0\M0_rpc;.\M4_rpc;.\M0_image;..\platform
  asm define: NO_CRP IPC_MASTER
  library: MicroLIB
  scatter file: ..\platform\M4_Ram.sct
  link misc: --debug --pad=0xFF  --keep=ipc_buffer.o(Master_mbxTable)
  group System Code
    ../platform/: startup_LPC43xx.s
    ../../../common/: scu.c core_cm4.c system_LPC43xx.c fpu_init.c emc_LPC43xx.c reloc_irq_table.c
  group Ipc
    ../../api/mbx/src/: ipc_buffer.c ipc_mbx.c
  group Platform
    ../platform/: platform_config.h platform_config.c
    ./M0_image/: CM0_image.c
  group Source Code
    ./: main.c
    ./M4_rpc/: master_mbx_callbacks.c
target LPC43xx_M4_FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: LPC43xx_M4_FLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 EXT_FLASH EXT_STAT_MEM IPC_MASTER
  c include: as above
  asm define: NO_CRP EXT_FLASH
  library: MicroLIB
  scatter file: ..\platform\M4_Flash.sct
  link misc: --debug --pad=0xFF --keep=ipc_buffer.o(Master_mbxTable)
